# Keil uVision project MecanumJog.uvprojx, settings and files
target MecanumJog (5060960::V5.06 update 7 (build 960)::.\Version5.06)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: MecanumJog +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\..\yyb_stm32\CORE;..\..\yyb_stm32\SYSTEM\delay;..\..\yyb_stm32\SYSTEM\sys;..\..\yyb_stm32\USER;..\..\yyb_stm32\FWLIB\inc;..\..\yyb_stm32\can_ZDT;..\..\yyb_stm32\LED
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CORE
    ../../yyb_stm32/CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../../yyb_stm32/FWLIB/src/: misc.c stm32f4xx_can.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_usart.c
  group SYSTEM
    ../../yyb_stm32/SYSTEM/delay/: delay.c
  group CAN_MOTOR
    ../../yyb_stm32/can_ZDT/: board.c Emm_V5.c
    ./: jog_can.c jog_can_diagnostics.c
  group USER
    ./: main.c hwt101.c
    ../../yyb_stm32/USER/: system_stm32f4xx.c
