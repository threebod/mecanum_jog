# Keil uVision project StationaryTransfer.uvprojx, settings and files
target StationaryTransfer (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: stationary_transfer +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,HSE_VALUE=8000000
  c misc: --c99
  c include: firmware;vendor\CORE;vendor\FWLIB\inc;vendor\Emm
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group StationaryTransfer
    firmware/: config.c main.c platform.c protocol.c system_stm32f4xx.c transfer.c syscalls.c
    vendor/Emm/: Emm_V5.c
    vendor/FWLIB/src/: misc.c stm32f4xx_rcc.c stm32f4xx_gpio.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_can.c
    vendor/CORE/: startup_stm32f40_41xxx.s
